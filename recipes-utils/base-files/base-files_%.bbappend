# Use our own fstab instead of the default one
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
